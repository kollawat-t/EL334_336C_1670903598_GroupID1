# Keil uVision project EL334_336C_1670903598_GroupID1.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: MK64FN1M0VLL12 NXP
  pack: NXP.MK64F12_DFP.14.0.0
  cpu: IRAM(0x14000000,0x1000) IRAM2(0x1fff0000,0x010000) IROM(0x00000000,0x100000) XRAM(0x20000000,0x030000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: EL334_336C_1670903598_GroupID1
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT6: RAM 0x20000000 size 0x30000
  memory RVCT9: RAM 0x14000000 size 0x1000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: .\RTE\Device\MK64FN1M0VLL12\MK64FN1M0xxx12_flash.scf
  group Source Group 1
    ./: main.c
software components: CMSIS:CORE 6.4.0, Device:CMSIS:MK64F12_header 1.0.0, Device:CMSIS:MK64F12_system 1.0.0, Device:Startup 1.1.0
